# Keil uVision project ModBusDemo1.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.2.0.3
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: ModBusDemo1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\modbus\include;.\modbus\rtu;.\modbus\ascii;.\modbus\port_1986BE1T
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group Source Group 1
    ./: main.c
  group ModBus
    ./modbus/: mb.c
    ./modbus/ascii/: mbascii.c
    ./modbus/functions/: mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./modbus/rtu/: mbcrc.c mbrtu.c
  group Port
    ./modbus/port_1986BE1T/: portevent.c portserial.c porttimer.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.0.3, Drivers:PORT 2.0.3, Drivers:RST_CLK 2.0.3, Drivers:TIMER 2.0.3, Drivers:UART 2.0.3
